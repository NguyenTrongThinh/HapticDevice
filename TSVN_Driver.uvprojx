# Keil uVision project TSVN_Driver.uvprojx, settings and files
target TSVN_Driver (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TSVN_Driver +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: .\Drivers;.\User;.\System\FreeRTOSV6.1.0\include;.\System\FreeRTOSV6.1.0\portable\MemMang;.\System\FreeRTOSV6.1.0\portable\RVDS\ARM_CM3;.\System\Libraries\CMSIS\CM3\CoreSupport;.\System\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\System\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./User/: main.c DeltaTask.c Delta.c Hardware.c Jacobian.c AMES_Matrix.c
  group FreeRTOS
    ./System/FreeRTOSV6.1.0/: list.c queue.c tasks.c
    ./System/FreeRTOSV6.1.0/portable/MemMang/: heap_2.c
    ./System/FreeRTOSV6.1.0/portable/RVDS/ARM_CM3/: port.c
  group BoardSupport
    ./Drivers/: AMES_BUTTON.c AMES_CLOCK.c AMES_LED.c AMES_PWM.c AMES_USART.c AMES_QEI.c AMES_PID.c AMES_TIMER.c AMES_EEPROM.c AMES_CAN.c AMES_ACS712.c AMES_FIR.c
  group Libraries
    ./System/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ./System/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
